## boards/hydrogreen/steering_wheel/board.yml
```yaml
board:
  name: steering_wheel
  full_name: Hydrogreen Steering wheel
  vendor: hydrogreen
  socs:
    - name: stm32g491xx
```
